# Keil uVision project csc-a.uvproj, settings and files
target DebugInRAM (ARM-ADS)
  device: LPC1768 NXP
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: CZC +hex
  c flags: Optim=1 OneElfS=1
  c include: .\CM3;.\LPC17xx;.\uCOS-II
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group CMSIS Files
    ./CM3/: core_cm3.c
    ./LPC17xx/Startup/: startup_LPC17xx.s
    ./LPC17xx/: system_LPC17xx.c
  group User Code
    ./USER_CODE/: main.c IRQ.h uart.c watchdog.c IO.c modbus.c task_modbus.c task_setup.c
  group uCOS-II
    ./uCOS-II/hook/: uCOS-II hook.lib
    ./uCOS-II/: OS_CFG.H INCLUDES.H uCOS_II.H uCOS-II.lib
target ReleasInFlash (ARM-ADS)
  device: LPC1768 NXP
  cpu: as above
  output: csc-a +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\CM3;.\LPC17xx;.\uCOS-II
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
